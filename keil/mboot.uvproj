# Keil uVision project mboot.uvproj, settings and files
target mboot (ARM-ADS)
  device: AT91SAM9M10 Atmel
  cpu: IRAM(0x300000-0x30FFFF) IROM(0x400000-0x40FFFF) CLOCK(400000000) CPUTYPE(ARM926EJ-S)
  output: mboot
  AfterMake: fromelf.exe --bin -o  ..\boot.bin "#L"
  c flags: Optim=1 wLevel=2
  c define: NOFPUT
  c misc: --gnu
  c include: ..\src;..\src\boot;..\src\drivers;..\src\fatfs
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x10000
  memory RVCT9: RAM 0x300000 size 0x10000
  scatter file: .\mboot-ddram.sct
  link misc: --entry HandlerReset
  group general
    ../src/: mboot.c mboot_.s media.c sdmmc.c sha204.c cp15.c cp15_.s shell.c math.c
  group boot
    ../src/boot/: init.c init_.s
  group driver
    ../src/drivers/: system.c uart.c dma.c mci_hs.c twi.c emac.c fpga.c rtc.c leds.c
  group fatfs
    ../src/fatfs/: ff.c diskio.c
